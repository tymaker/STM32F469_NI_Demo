# Keil uVision project STM32469I_DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32469I_DEMO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_DISCOVERY
  c include: ..\User;..\Src;..\Inc;..\..\..\Drivers\STM32F4xx_HAL_Driver\Src;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\Drivers\FatFs\src;..\..\..\Drivers\FatFs\src\drivers
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Example/User
    ../User/: main.c stm32f4xx_it.c stm32f4xx_hal_conf.h
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c
  group Example/MDK-ARM
    ../../../Drivers/: startup_stm32f469xx.s
  group Drivers/BSP/STM32F469I-Discovery
    ../Src/: stm32f469_fmc_sdram.c stm32f469_usart3.c
    ../../../Drivers/FatFs/src/drivers/: sdram_diskio.c
  group Drivers/CMSIS
    ../User/: system_stm32f4xx.c
  group FatFs/Core
    ../../../Drivers/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 3.40.0
